Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2020-05-14T13:08:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 14 13:08:55 2020 * Host: PC-029 * Database: C:\Users\PC-029\AppData\Local\Temp\{A8A81780-52BD-47CB-B7B5-40688F3BEFA5}\ifc * Database version: 5507 * Database creation date: Thu May 14 13:08:54 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 14 13:08:55 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 14 13:08:55 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: \\192.168.1.99\Production 2\2020\14- MARK\Working\IFC\14.05.2020\SAF608_TDS.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: SAF608, SAF608_TDS:SAF608:3137
In: Level 1
Type - Identity Data - comments: Same handle as SAF606; Description: Enware-Oras Safira In-Wall Compact Shower Mixer; Information: website link: www.enware.com.au; Product Code: SAF608; Type Name: SAF608
Type - Other - Category: Generic Models; Family Name: SAF608_TDS
Pset_BuildingElementProxyCommon - Reference: SAF608
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.0282194 m2; Volume: 0.000315243 m3
Other - Family: SAF608_TDS: SAF608; Family and Type: SAF608_TDS: SAF608; Type: SAF608_TDS: SAF608; Type Id: SAF608_TDS: SAF608
Phasing - Phase Created: New Construction
